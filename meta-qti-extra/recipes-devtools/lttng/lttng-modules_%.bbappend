FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += " file://0001-lttng-module-fix-lttng-module-compile-issue.patch "
