RDEPENDS_${PN} += "\
    pulseaudio-module-codec-control \
    agl-audio-plugin \
    pulseaudio-module-acdb \
"

