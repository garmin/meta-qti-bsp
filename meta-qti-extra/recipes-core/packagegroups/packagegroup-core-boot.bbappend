# Add the libgomp support.
RDEPENDS_${PN} += "\
    libgomp libgomp-dev libgomp-staticdev \
    "
