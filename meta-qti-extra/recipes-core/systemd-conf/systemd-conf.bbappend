FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI += " file://0001-ignore-power-key-event-to-avoid-poweroff.patch "
