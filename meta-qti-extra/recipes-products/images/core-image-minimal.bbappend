# Add the libgomp support.

IMAGE_INSTALL += "libgomp libgomp-dev libgomp-staticdev"

