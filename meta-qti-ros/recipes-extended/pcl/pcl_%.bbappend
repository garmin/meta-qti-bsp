EXTRA_OECMAKE += "-DLIB_INSTALL_DIR=${baselib}"
