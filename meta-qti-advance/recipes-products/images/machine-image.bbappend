include ${BASEMACHINE}/${BASEMACHINE}-image.inc

include common-image.inc
