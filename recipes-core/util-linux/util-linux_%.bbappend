ALTERNATIVE_${PN}-readprofile_remove_sdm845 = "readprofile" 
