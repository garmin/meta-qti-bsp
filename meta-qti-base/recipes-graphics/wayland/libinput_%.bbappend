
FILESEXTRAPATHS_append := ":${THISDIR}/libinput"

SRC_URI += "file://0002-libinput-fix-race-condition-for-device-add.patch"
