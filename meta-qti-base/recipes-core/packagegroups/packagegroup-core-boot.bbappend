
RDEPENDS_${PN} += "\
    packagegroup-qti-core-boot-prop \
    "
