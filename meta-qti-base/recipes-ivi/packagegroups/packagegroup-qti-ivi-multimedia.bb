SUMMARY = "QTI package group for ivi multimedia middlewares"

inherit packagegroup

PACKAGES = "\
    packagegroup-qti-ivi-multimedia \
    "

ALLOW_EMPTY_${PN} = "1"

RDEPENDS_${PN} += "\
    "
