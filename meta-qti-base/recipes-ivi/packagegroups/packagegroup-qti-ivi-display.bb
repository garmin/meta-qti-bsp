SUMMARY = "QTI package group for ivi display middlewares"

inherit packagegroup

PACKAGES = "\
    packagegroup-qti-ivi-display \
    "

ALLOW_EMPTY_${PN} = "1"

RDEPENDS_${PN} += "\
    "
