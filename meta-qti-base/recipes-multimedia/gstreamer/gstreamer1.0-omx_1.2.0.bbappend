SRC_URI = "file://gst-omx"
SRC_URI += "git://codeaurora.org/quic/le/gstreamer/common;destsuffix=gst-omx/common;branch=gstreamer/common/master;name=common"