# Fix the GPLv2 compile error.
CFLAGS += "-Wno-error=format-truncation"
