SRC_URI = "${CAF_GIT}/platform/external/update-rc.d;protocol=git;branch=github/master \
          "

PR = "r6"
