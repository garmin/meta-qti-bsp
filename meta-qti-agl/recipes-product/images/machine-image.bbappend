IMAGE_INSTALL += "packagegroup-agl-profile-graphical"
