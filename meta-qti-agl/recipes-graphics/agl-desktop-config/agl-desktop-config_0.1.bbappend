# Make agl-desktop-config compatible with multilib
export libdir="/usr/lib"
