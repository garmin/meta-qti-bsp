EXTRA_OECMAKE += "-DLIB_SUFFIX=''"
