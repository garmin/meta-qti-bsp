RDEPENDS_${PN}_remove = "agl-service-geoclue"
