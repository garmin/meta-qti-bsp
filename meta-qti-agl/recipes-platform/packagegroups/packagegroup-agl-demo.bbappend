RDEPENDS_${PN}_remove = " \
    udisks \
    audiomanager \
    "
