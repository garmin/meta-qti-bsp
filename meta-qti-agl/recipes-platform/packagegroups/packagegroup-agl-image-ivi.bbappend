RDEPENDS_${PN}_remove = " \
    packagegroup-agl-ivi-multimedia \
    packagegroup-agl-ivi-graphics \
    "
