RDEPENDS_${PN}_remove = "\
    agl-service-bluetooth \
    agl-service-bluetooth-map \
    agl-service-bluetooth-pbap \
    "
