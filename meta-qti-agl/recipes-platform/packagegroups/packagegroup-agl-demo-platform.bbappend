AGL_APPS_remove = " \
    virtual/navigation \
    "

AGL_APIS = " "
