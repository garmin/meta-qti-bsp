RDEPENDS_${PN}_remove = "\
    packagegroup-agl-core-connectivity \
    packagegroup-agl-core-multimedia \
    "
