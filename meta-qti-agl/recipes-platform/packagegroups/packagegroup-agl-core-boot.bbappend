RDEPENDS_${PN}_remove = "\
    distro-build-manifest \
    "
