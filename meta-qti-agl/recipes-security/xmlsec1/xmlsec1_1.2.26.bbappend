SRC_URI = "git://source.codeaurora.org/quic/le/xmlsec;branch=terabit/master;protocol=https"
SRCREV = "72a0a04283b45ec7a626759a323cc3f6517eba34"

S = "${WORKDIR}/git"
