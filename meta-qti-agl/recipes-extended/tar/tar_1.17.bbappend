# Fix build error when enable meta-gplv2
CFLAGS += "-Wno-error=format-security"
