# Add plugins.
RDEPENDS_${PN} += "\
    lightmediascanner-plugin-id3 \
    lightmediascanner-plugin-video-dummy \
    lightmediascanner-plugin-m3u \
    lightmediascanner-plugin-ogg \
    lightmediascanner-plugin-wave \
    lightmediascanner-plugin-dummy \
    lightmediascanner-plugin-jpeg \
    lightmediascanner-plugin-mp4 \
    lightmediascanner-plugin-flac \
    lightmediascanner-plugin-png \
    lightmediascanner-plugin-pls \
    lightmediascanner-plugin-audio-dummy \
"
