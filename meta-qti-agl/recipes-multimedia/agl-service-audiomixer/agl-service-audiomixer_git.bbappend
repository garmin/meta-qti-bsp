RDEPENDS_${PN} += "\
    pipewire \
    "
