FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_append += "file://0001-libqtappfw-fix-multilib-compatibility.patch"

