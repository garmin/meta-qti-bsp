RDEPENDS_${PN}_remove = "agl-service-bluetooth-pbap"
