inherit qticlang

DEPENDS += "clang-native"

CLANG_BIN_PATH = "${STAGING_BINDIR_NATIVE}/"