# Androidmk files are no more supported move to autotools.
